LICENSE = "GPLv2"
